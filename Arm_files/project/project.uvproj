# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: project +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c kpm.c Edit_Fun.c esp01.c uart0.c i2c_eeprom.c
    ./RTC_LPC2148/RTC_LPC2148/: mainrtc.c
    ../: lcd.c delay.c i2c.c
    ./LPC2148_DHT11_LCD/: dht11.c
